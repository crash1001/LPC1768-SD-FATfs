# Keil uVision project sd-interface.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.5.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: sd-interface +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\src\Drivers\include;.\src\Monitor;.\src\FatFs;.\src\LPC1700\SPI_SD
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group main
    ./src/: main.c
    ./src/Monitor/: monitor.c uart_console.c
  group drivers
    ./src/Drivers/source/: lpc17xx_clkpwr.c lpc17xx_gpio.c lpc17xx_libcfg_default.c lpc17xx_pinsel.c lpc17xx_uart.c
  group fatfs
    ./src/FatFs/: ff.c
    ./src/LPC1700/SPI_SD/: sd.c sd_lpc17xx_spi.c
    ./src/FatFs/option/: ccsbcs.c
software components: CMSIS:CORE 5.2.0, CMSIS:DSP 1.6.0, Device:Startup 1.0.0
